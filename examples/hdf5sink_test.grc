<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_filename</value></param>
<param><key>value</key><value>"/tmp/dataset.hdf5"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>analog_random_uniform_source_x</key>
<param><key>id</key><value>analog_random_uniform_source_x_0</value></param>
<param><key>maximum</key><value>255</value></param>
<param><key>minimum</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_random_uniform_source_x</key>
<param><key>id</key><value>analog_random_uniform_source_x_0_0</value></param>
<param><key>maximum</key><value>255</value></param>
<param><key>minimum</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_random_uniform_source_x</key>
<param><key>id</key><value>analog_random_uniform_source_x_0_1</value></param>
<param><key>maximum</key><value>255</value></param>
<param><key>minimum</key><value>0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_random_uniform_source_x</key>
<param><key>id</key><value>analog_random_uniform_source_x_0_2</value></param>
<param><key>maximum</key><value>255</value></param>
<param><key>minimum</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>hdf5_sink_x</key>
<param><key>id</key><value>hdf5_sink_x_0</value></param>
<param><key>data_filename</key><value>data_filename</value></param>
<param><key>dataset_name</key><value>'dataset_b'</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>log_filename</key><value></value></param>
<param><key>log_level</key><value>logging.DEBUG</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>shrink</key><value>True</value></param>
</block>
<block>
<key>hdf5_sink_x</key>
<param><key>id</key><value>hdf5_sink_x_0_0</value></param>
<param><key>data_filename</key><value>data_filename</value></param>
<param><key>dataset_name</key><value>'dataset_s'</value></param>
<param><key>type</key><value>short</value></param>
<param><key>log_filename</key><value></value></param>
<param><key>log_level</key><value>logging.DEBUG</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>shrink</key><value>True</value></param>
</block>
<block>
<key>hdf5_sink_x</key>
<param><key>id</key><value>hdf5_sink_x_0_1</value></param>
<param><key>data_filename</key><value>data_filename</value></param>
<param><key>dataset_name</key><value>'dataset_i'</value></param>
<param><key>type</key><value>int</value></param>
<param><key>log_filename</key><value></value></param>
<param><key>log_level</key><value>logging.DEBUG</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>shrink</key><value>True</value></param>
</block>
<block>
<key>hdf5_sink_x</key>
<param><key>id</key><value>hdf5_sink_x_0_2</value></param>
<param><key>data_filename</key><value>data_filename</value></param>
<param><key>dataset_name</key><value>'dataset_f'</value></param>
<param><key>type</key><value>float</value></param>
<param><key>log_filename</key><value></value></param>
<param><key>log_level</key><value>logging.DEBUG</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>shrink</key><value>True</value></param>
</block>
<connection><source_block_id>analog_random_uniform_source_x_0</source_block_id><sink_block_id>hdf5_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_uniform_source_x_0_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_uniform_source_x_0_1</source_block_id><sink_block_id>hdf5_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_uniform_source_x_0_2</source_block_id><sink_block_id>hdf5_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>hdf5_sink_x_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
